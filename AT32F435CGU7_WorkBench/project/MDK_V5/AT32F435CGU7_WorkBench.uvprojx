# Keil uVision project AT32F435CGU7_WorkBench.uvprojx, settings and files
target Deta1_AT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DETA40_AT32 +hex
  BeforeMake: "..\..\devicetree\devicetree_generator.exe" "..\..\devicetree\Deta1.dts" N NoBro
  AfterMake: FDICreater.exe --replace 0x08010000|0x200 --hver 0x0001010000 --name DETA-40N --hname DETA-40N #H
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGU7,USE_STDPERIPH_DRIVER,HAS_ICM42688,
  c misc: --diag_suppress=1035,177,550
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\Device_Application_Layer\inc;..\..\Device_Hardware_Layer\LSM6DSR;..\..\Device_Hardware_Layer;..\..\Device_Hardware_Layer\rtio\inc;..\..\Device_Services_Layer\inc;..\..\Tool\inc;..\..\Device_Hardware_Layer\xv7001;..\..\Device_Hardware_Layer\SCHA16T;..\..\Device_Hardware_Layer\ICM42688;..\..\Device_Hardware_Layer\ICM42688\Invn\Drivers\Icm426xx;..\..\Device_Hardware_Layer\ICM42688\Invn;..\..\devicetree
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\objects\AT32F435CGU7_WorkBench.sct
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c wk_usart.c wk_dma.c wk_tmr.c wk_exint.c wk_spi.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_flash.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group device_serives_layer
    ../../Device_Services_Layer/src/: spi_serve.c uart_serve.c
    ../../Device_Application_Layer/src/: FDILink.c
  group device_application_layer
    ../../Tool/src/: FDILinkManager.c
    ../../Device_Application_Layer/src/: imu_task.c
  group device_hardeware_layer
    ../../Device_Hardware_Layer/: sensor.c
    ../../Device_Hardware_Layer/rtio/src/: rtio.c
    ../../Device_Hardware_Layer/LSM6DSR/: LSM6DSR.c
    ../../Device_Hardware_Layer/SCHA16T/: SCHA16T.c
    ../../Device_Hardware_Layer/xv7001/: xv7001.c
    ../../Device_Hardware_Layer/ICM42688/: icm42688.c
    ../../Device_Hardware_Layer/ICM42688/Invn/Drivers/Icm426xx/: Icm426xxDriver_HL.c Icm426xxDriver_HL_apex.c
  group tool
    ../../Tool/src/: Verify_Tool.c Queue.c TD.c
  group device_tree
    ../../devicetree/: devicetree_generated.h
target Deta10_AT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: as above
  output: DETA10_AT32 +hex
  BeforeMake: "..\..\devicetree\devicetree_generator.exe" "..\..\devicetree\Deta10.dts" N NoBro
  AfterMake: FDICreater.exe --replace 0x08010000|0x200 --hver 0x0001010000 --name DETA-10N --hname DETA-10N #H
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGU7,USE_STDPERIPH_DRIVER,HAS_ICM42688,
  c misc: --diag_suppress=1035,177,550
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\objects\AT32F435CGU7_WorkBench.sct
target Deta20_AT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: as above
  output: DETA40_AT32 +hex
  BeforeMake: "..\..\devicetree\devicetree_generator.exe" "..\..\devicetree\Deta20.dts" N NoBro
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGU7,USE_STDPERIPH_DRIVER,HAS_ICM42688,
  c misc: --diag_suppress=1035,177,550
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\objects\AT32F435CGU7_WorkBench.sct
target Deta40_AT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: as above
  output: DETA40_AT32 +hex
  BeforeMake: "..\..\devicetree\devicetree_generator.exe" "..\..\devicetree\Deta40.dts" N NoBro
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGU7,USE_STDPERIPH_DRIVER,HAS_ICM42688,
  c misc: --diag_suppress=1035,177,550
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\objects\AT32F435CGU7_WorkBench.sct
software components: RTOS:kernel 3.1.2
